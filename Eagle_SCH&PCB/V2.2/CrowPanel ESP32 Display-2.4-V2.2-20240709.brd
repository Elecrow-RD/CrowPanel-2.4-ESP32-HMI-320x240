# Repository Elecrow-RD/CrowPanel-2.4-ESP32-HMI-320x240

File readme.md:

### 1, Product picture

### 2, Product version number

|      | Hardware | Software | Remark |
| ---- | -------- | -------- | ------ |
| 1    | V1.0     | V1.0     | old |
| 1    | V1.1     | V1.0     | old |
| 1    | V2.0     | V1.0     | old |
| 1    | V2.1     | V1.0     | latest |

**Version 2.0/2.1** upgrades the automatic download feature from Version 1.0.

### 3, product information

- Model: 2.4 inches-CrowPanel ESP32 display
- Main Processor: ESP32-WROOM-32-N4
- Resolution: 240*320
- Touch Type: Resistive Touch Screen
- Display Type: TN Panel
- Screen: TFT-LCD Screen
- Display driver: ILI9341V
- External power supply: DC5V-2A
- Interface: 1\*TF Card Slot, 1* I2C, 1* GPIO, 1\*Speak, 1* UART1, 1*UART0
- Button: BOOT Button and Reset Button
- Active Area: 36.72\*48.96mm(W*H)
- Working Temperature: -20℃～70℃
- Storage Temperature: -30℃～80℃

### 4, Use the driver module

| Name | dependency library |
| ---- | ------------------ |
| LVGL | lvgl/lvgl@8.3.3    |

### 5,Quick Start

##### Arduino IDE starts

1.Download the library files used by this product to the 'libraries' folder.

C:\Users\Documents\Arduino\libraries\

2.Open the Arduino IDE

3.Open the code configuration environment and burn it

##### ESP-IDF starts

1.Right-click on an empty space in the project folder and select "Open with VS Code" to open the project.

2.In the IDF plug-in, select the port, then compile and flash

##### PlatformIO starts

1.Right-click on an empty space in the project folder and select "Open with VS Code" to open the project.

2.In the PlatformIO plug-in, select the port, then compile and flash

##### Micropython starts

1,Right-click on an empty space in the project folder and select "Thonny" to open the project.

2,In thonny software, select the master and port, then run the program

### 6,Folder structure.

|--3D file： Contains 3D model files (.stp) for the hardware. These files can be used for visualization, enclosure design, or integration into CAD software.

|--Datasheet: Includes datasheets for components used in the project, providing detailed specifications, electrical characteristics, and pin configurations.

|--Eagle_SCH&PCB: Contains **Eagle CAD** schematic (`.sch`) and PCB layout (`.brd`) files. These are used for circuit design and PCB manufacturing.

|--example: Provides example code and projects to demonstrate how to use the hardware and libraries. These examples help users get started quickly.

|--factory_firmware: Stores pre-compiled factory firmware that can be directly flashed onto the device. This ensures the device runs the default functionality.

|--factory_sourcecode: Contains the source code for the factory firmware, allowing users to modify and rebuild the firmware as needed.

### 7,Pin definition

#define SD_MOSI 23

#define SD_MISO 19

#define SD_SCK 18

#define SD_CS 5

iic:

  Wire.begin(22, 21);

\#define TFT_BL   27            // LED back-light control pin

#define TFT_MISO 12 

#define TFT_MOSI 13 // In some display driver board, it might be written as "SDA" and so on. 

#define TFT_SCLK 14 #define TFT_CS   15  // Chip select control pin 

#define TFT_DC   2  // Data Command control pin 

#define TFT_RST  -1  // Reset pin (could connect to Arduino RESET pin) 

#define TFT_BL   27  // LED back-light 

#define TOUCH_CS 33     // Chip select pin (T_CS) of touch screen

## EAGLE design Eagle_SCH&PCB/V2.2/CrowPanel ESP32 Display-2.4-V2.2-20240709.brd

Parts:
C1: 10uF; DISCRETE_C0603
C2: 100nF; DISCRETE_C0603
C3, C4, C9, C10, C12, C13, C15, C16, C17, C23, C26: 100nF; 0603
C5, C24, C25: 10uF; 0805_S
C6, C8: 1uF; 0603
C7, C42: 22uF; 0805
C11: 4.7uF; 0603
C14: 0.39uF; DISCRETE_C0603
C18, C19, C20, C21: 100pF; 0603
C22, C53, C55: 1uF; DISCRETE_C0603
C27: 100nF; C0603
C28: 4.7uF/NC; 0603
C46: 1nF; DISCRETE_C0603
C51: 100pF; DISCRETE_C0603
C54: 4.7uF; DISCRETE_C0603
D2: IN5817; DO-214AC
D3: S2M/SMB; 214AB
J1: QD281801; QD241801-18PIN*0.8
J3: USB_TYPE-C_16PIN3.0USB; KEVIN_3.0TYPEC-SMD
J5, J8: PH2.0WT-2PIN
J6, J7, J10: CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE90D; CONNECTOR_4P-SMD-2.0-90D
K1, K4: BUTTON; 157SW
L4: 5.6UH; CD54_CD54
LED1: RED; DISCRETE_LED-0603
Q3: PMOS-3401-4A; SOT-23
Q6: 2N7002; SOT23
Q9, Q10: S9013; SOT23@1
R1, R18, R25, R26, R27, R28, R29, R74, R75: 1K; DISCRETE_R0603
R2, R35: 10K/NC; DISCRETE_R0603
R3, R12: 4.7K; DISCRETE_R0603
R4: 10K; R0603
R5, R19: 0R; DISCRETE_R0603
R6, R10, R16, R17, R21, R23, R24, R38, R67: 10K; DISCRETE_R0603
R7: 3.9R; DISCRETE_R0603
R8: NC/1K; DISCRETE_R0603
R9: 2K; DISCRETE_R0603
R11, R32, R71, R72: 22R; DISCRETE_R0603
R20: 45.3K; DISCRETE_R0603
R22: 22K; DISCRETE_R0603
R30, R31: 0Ω; DISCRETE_R0603
R33, R34: 5.1K; DISCRETE_R0603
R37: 68K; DISCRETE_R0603
SD1: HOLDER-MICROSD-9P; 9P-SMD-W/-RING
U1: RY3420; A_XBJ_SOT23-5
U2: SC8002B; AT24C02_SOP8
U3: XPT2046; XP2046-SSOP16
U6: CH340C; SOP-16
U24: U24; ESP32-WROOM-32-N4
U26: 4054A; SOP23-5

Connections:
3.3V: C12.2, C55.2, R31.1, U2.6 (VDD)
3V3: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C9.2, C10.2, C13.2, C15.2, C16.2, C17.2, C22.2, C23.2, C26.1, C54.2, J1.P$9 (VCC), J1.P$10 (LED-A), J6.3, J7.3, J10.3, L4.2, R1.2, R3.2, R4.1, R8.2, R10.2, R16.1, R17.1, R18.2, R20.1, R23.1, R24.1, R26.2, R27.2, R28.2, R29.2, R31.2, R35.1, R67.1, SD1.4 (VDD), U3.1 (VCC), U3.9 (VREF), U3.10 (IOVDD), U6.4 (V3), U6.16 (VCC), U24.2 (VDD33)
AGND: C12.1, C46.1, C51.1, C53.2, C55.1, J8.P$3, J8.P$4, R30.1, U2.1 (SHUTDOWN), U2.7 (GND)
BAT+: C5.2, C24.2, D2.A, J5.P$1, Q3.3 (D), U26.3 (BAT)
BYPASS_IN+: C53.1, U2.2 (BYPASS), U2.3 (+IN)
D+: J3.A6 (DP1), J3.B6 (DP2), R32.1
D-: J3.A7 (DN1), J3.B7 (DN2), R11.1
DTR: Q10.2 (E), R75.2, U6.13 (DTR#)
EN_RESET: C11.1, K4.2, Q9.3 (C), R4.2, R5.2, U24.3 (EN)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.2, C13.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.2, C27.2, C28.2, C42.1, C54.1, J1.P$1 (GND), J1.P$8 (GND2), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.P$6, J3.P$7, J3.P$8, J3.P$9, J5.P$2, J5.P$3, J5.P$4, J6.4, J6.SS1, J6.SS2, J7.4, J7.SS1, J7.SS2, J10.4, J10.SS1, J10.SS2, K1.1, K4.1, LED1.-, Q6.2 (S), R2.2, R6.1, R9.2, R21.2, R30.2, R33.2, R34.1, R38.2, SD1.6 (VSS), SD1.G1, SD1.G2, SD1.G3, SD1.G4, U1.2 (GND), U3.6 (GND), U6.1 (GND), U24.1 (GND), U24.15 (GND), U24.38 (GND), U24.41 (GND), U24.42 (GND), U24.43 (GND), U24.44 (GND), U24.45 (GND), U24.46 (GND), U24.47 (GND)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
IN-: R22.2, R37.1, U2.4 (-IN)
IO0_BOOT: K1.2, Q10.3 (C), U24.25 (GPIO0,ADC2_CH1,TOUCH1,RTC_GPIO11,CLK_OU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)
IO2_TFT_RS: J1.P$4 (D/C), U24.24 (GPIO2,ADC2_CH2,TOUCH2,RTC_GPIO12,HSPIWP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)
IO4_PROT_A/D: U24.26 (GPIO4,ADC2_CH0,TOUCH0,RTC_GPIO10,HSPIHD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)
IO5_TF_CS: R67.2, SD1.2 (CD/DATA3), U24.29 (GPIO5,VSPICS0,HS1_DATA6,EMAC_RX_CLK)
IO12_TFT_SDO/TP_OUT: R2.1, U3.15 (CS), U24.14 (GPIO12,ADC2_CH5,TOUCH5,RTC_GPIO15,MTDI,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)
IO13_TFT_SDI/TP_DIN: J1.P$6 (SDA), R29.1, U3.14 (DIN), U24.16 (GPIO13,ADC2_CH4,TOUCH4,RTC_GPIO14,MTCK,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)
IO14_TFT_CLK/TP_CLK: J1.P$3 (SCL), R28.1, U3.16 (DCLK), U24.13 (GPIO14,ADC2_CH6,TOUCH6,RTC_GPIO16,MTMS,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)
IO15_TFT_CS: J1.P$5 (CS), U24.23 (GPIO15,ADC2_CH3,TOUCH3,MTDO,HSPICS0,RTC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)
IO16_RXD2: J10.1, U24.27 (GPIO16,HS1_DATA4,U2RXD,EMAC_CLK_OUT)
IO17_TXD2: J10.2, U24.28 (GPIO17,HS1_DATA5,U2TXD,EMAC_CLK_OUT_180)
IO18_TF_SPI_CLK: SD1.5 (SCLK), U24.30 (GPIO18,VSPICLK,HS1_DATA7)
IO19_TF_SPI_MISO: R24.2, SD1.7 (DATA0), U24.31 (GPIO19,VSPIQ,U0CTS,EMAC_TXD0)
IO21_SCL: J6.1, R26.1, U24.33 (GPIO21,VSPIHD,EMAC_TX_EN)
IO22_SDA: J6.2, R27.1, U24.36 (GPIO22,VSPIWP,U0RTS,EMAC_TXD1)
IO23_TF_SPI_MOSI: R23.2, SD1.3 (CMD), U24.37 (GPIO23,VSPID,HS1_STROBE)
IO25_PROT_A/D: J7.1, R18.1, U24.10 (GPIO25,DAC_1,ADC2_CH8,RTC_GPIO6,EMAC_RX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)
IO26_SPEAK: R12.1, U24.11 (GPIO26,DAC_2,ADC2_CH9,RTC_GPIO7,EMAC_RX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)
IO27_LCD_BLK_CTR: Q6.1 (G), R38.1, U24.12 (GPIO27,ADC2_CH7,TOUCH7,RTC_GPIO17,EMAC_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)
IO32_PROT_A/D: J7.2, R1.1, U24.8 (GPIO32,XTAL_32K_P,ADC1_CH4,TOUCH9,RTC_G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)
IO33_TP_CS: U3.12 (DOUT), U24.9 (GPIO33,XTAL_32K_N,ADC1_CH5,TOUCH8,RTC_G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)
IO34_PROT_A/D: U24.6 (GPIO34,ADC1_CH6,RTC_GPIO4)
IO35_PROT_A/D: U24.7 (GPIO35,ADC1_CH7,RTC_GPIO5)
IO36_TP_IRQ: R10.1, U3.11 (PENIRQ), U24.4 (SENSOR_VP,GPIO36,ADC1_CH0,RTC_GPIO0)
IO39_PROT_A: U24.5 (SENSOR_VN,GPIO39,ADC1_CH3,RTC_GPIO3)
unnamed: LED1.+, R3.1
unnamed: Q6.3 (D), R7.2
unnamed: C46.2, R12.2, R19.1
unnamed: R35.2, U3.7 (VBAT)
unnamed: R9.1, U26.5 (PROG)
unnamed: J1.P$11 (LED-K), J1.P$12 (LED-K2), J1.P$13 (LED-K3), J1.P$14 (LED-K4), R7.1
unnamed: L4.1, U1.3 (SW)
unnamed: J3.B5 (CC2), R33.1
unnamed: J3.A5 (CC1), R34.2
unnamed: Q3.1 (G), R6.2, R25.1
unnamed: R20.2, R21.1, U1.5 (FB)
unnamed: C14.1, C51.2, R19.2
unnamed: C14.2, R22.1
unnamed: Q9.1 (B), R75.1
unnamed: Q10.1 (B), R74.1
unnamed: R72.2, U6.2 (TXD)
unnamed: R71.2, U6.3 (RXD)
unnamed: R16.2, SD1.1 (DATA2)
unnamed: R17.2, SD1.8 (DATA1)
RTS: Q9.2 (E), R74.2, U6.14 (RTS#)
TFT_RESET: C28.1, J1.P$2 (RESET), R5.1, R8.1
TP_X+: C18.2, J1.P$15 (XL), U3.2 (XP)
TP_X-: C20.2, J1.P$17 (XR), U3.4 (XN)
TP_Y+: C19.2, J1.P$18 (YD), U3.3 (YP)
TP_Y-: C21.2, J1.P$16 (YU), U3.5 (YN)
UART0_RXD0: R72.1, U24.34 (RXD0,GPIO3,CLK_OUT2)
UART0_TXD0: R71.1, U24.35 (TXD0,GPIO1,CLK_OUT3,EMAC_RXD2)
USB_D+: R32.2, U6.5 (UD+)
USB_D-: R11.2, U6.6 (UD-)
VBUS: C25.2, C27.1, D3.1 (+), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R25.2, U26.4 (VCC)
VIN: C6.2, C42.2, D2.C, D3.2 (-), Q3.2 (S), U1.1 (EN), U1.4 (VIN)
VO1: J8.P$1, R37.2, U2.5 (VO1)
VO2: J8.P$2, U2.8 (VO2)

Notes on the sheet:
Vout=0.6*(R20/R21 +1)=3.3V
系统3.3V电源
UART1接口
主控 ESP32-WROOM-32-N4
USB type-c座子
电池及控制电路
IO0: 低电平：下载启动 高电平：SPI启动
EN: 高电平：芯片使能； 低电平：芯片关闭。
USB转串口
SPEAK 功放
TF Card
BOOT
RESET
POWER LED
LCD+TP 接口
TP驱动:XPT2046
Auto_DOWNLOAD
500mA
BAT

Board: 2 copper layers, 76.8 x 46.7 mm, 100 parts (2 on the bottom side), 64 nets.

Other parts of the board:
U$2: 2.4板框
U$3: LOGE-2.0
U$37: LOGLE

## Commit log (part)

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2025-03-19 修改了单个文件
2026-04-19 Fix formatting issues in readme.md
2026-06-15 V2.1
2026-06-22 Micropython
2026-06-22 ESP_IDF
2026-06-23 PlatformIO
2026-06-25 .gitignore
2026-06-25 .pio
